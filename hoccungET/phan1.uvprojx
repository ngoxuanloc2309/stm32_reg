# Keil uVision project phan1.uvprojx, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: phan1
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: main.c
  group Driver
    ./Driver/: rcc.c rcc.h gpio.c gpio.h afio.c afio.h exti.c exti.h type.h timer.c timer.h adc.c adc.h SPI.c SPI.h USB.c USB.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
